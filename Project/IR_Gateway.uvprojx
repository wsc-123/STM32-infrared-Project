# Keil uVision project IR_Gateway.uvprojx, settings and files
target IR_Gateway (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x8000000,0xE000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: IR_Gateway +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Firmware\User;..\Firmware\Bsp;..\Firmware\App;..\Libraries\CMSIS;..\Libraries\StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\IR_Gateway.sct
  group User
    ../Firmware/User/: main.c stm32f10x_it.c
  group Bsp
    ../Firmware/Bsp/: bsp_delay.c bsp_led.c bsp_usart.c bsp_ir_tx.c bsp_ir_rx.c ir_codes.c bsp_flash.c bsp_oled.c bsp_esp_at.c bsp_watchdog.c
  group App
    ../Firmware/App/: cmd_parser.c midea_ac.c
  group StdPeriph_Driver
    ../Libraries/StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_flash.c
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c startup_stm32f10x_md.s
  group Doc
    ../Firmware/: README.md
