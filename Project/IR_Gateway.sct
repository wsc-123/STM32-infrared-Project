LR_IROM1 0x08000000 0x0000E000  {
  ER_IROM1 0x08000000 0x0000E000  {
    *.o (RESET, +First)
    *(InRoot$$Sections)
    .ANY (+RO)
  }
  RW_IRAM1 0x20000000 0x00005000  {
    .ANY (+RW +ZI)
  }
}
